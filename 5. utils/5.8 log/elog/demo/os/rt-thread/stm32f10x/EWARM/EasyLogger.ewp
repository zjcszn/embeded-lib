# IAR project EasyLogger.ewp, settings and files
configuration stm32f103xE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\app\inc; ..\components\rtt_uart; ..\components\easyflash\inc; ..\components\easylogger\inc; ..\components\easylogger\plugins\flash; ..\components\others; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\RT-Thread-1.2.2\include; ..\RT-Thread-1.2.2\components\drivers\include; ..\RT-Thread-1.2.2\components\drivers\include\drivers; ..\RT-Thread-1.2.2\components\finsh; ..\Libraries\CMSIS_EWARM\Include; ..\Libraries\CMSIS_EWARM\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\easylogger\inc; ..\..\..\..\..\easylogger\plugins\flash
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: EasyFlash.bin
  ILINK.IlinkOutputFile: EasyLogger.out
  ILINK.IlinkIcfFile: ..\components\others\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/src/: app.c app_task.c stm32f10x_it.c user_finsh_cmd.c
    ../app/inc/: rtconfig.h
  group components/easyflash/port
    ../components/easyflash/port/: ef_port.c
  group components/easyflash/src
    ../components/easyflash/src/: easyflash.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
  group components/easylogger/plugins/flash
    ../../../../../easylogger/plugins/flash/: elog_flash.c
    ../components/easylogger/plugins/flash/: elog_flash_port.c
  group components/easylogger/port
    ../components/easylogger/port/: elog_port.c
  group components/easylogger/src
    ../../../../../easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group components/others
    ../components/others/: bsp.c utils.c
  group components/rtt_uart
    ../components/rtt_uart/: usart.c
  group libs/cmsis
    ../Libraries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS_EWARM/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group libs/std_periph_driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group rt_thread_1.2.2/drivers
    ../RT-Thread-1.2.2/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c wrokqueue.c
    ../RT-Thread-1.2.2/components/drivers/serial/: serial.c
  group rt_thread_1.2.2/finsh
    ../RT-Thread-1.2.2/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rt_thread_1.2.2/kernel
    ../RT-Thread-1.2.2/src/: clock.c cpuusage.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c module.h object.c scheduler.c slab.c thread.c timer.c
  group rt_thread_1.2.2/libcpu
    ../RT-Thread-1.2.2/libcpu/arm/cortex-m3/: context_iar.S cpuport.c
