# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072VZ STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: demo
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;..\..\..\mbmaster\include;..\port
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c timers.c queue.c croutine.c list.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_rcc.c stm32l0xx_hal_tim.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_flash_ramfunc.c
  group Application/User
    ../Src/: main.c freertos.c stm32l0xx_hal_msp.c stm32l0xx_it.c usart.c dma.c gpio.c tim.c
  group MODBUS
    ../../../mbmaster/: mbm.c
    ../../../mbmaster/ascii/: mbmascii.c
    ../../../mbmaster/common/: mbutils.c
    ../../../mbmaster/functions/: mbmfunccoils.c mbmfunccustom1.c mbmfuncdisc.c mbmfuncfiles.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c mbmfuncslaveid.c
    ../../../mbmaster/rtu/: mbmcrc.c mbmrtu.c
  group MODBUS port
    ../port/: mbportevent.c mbportother.c mbport.h mbsconfig.h mbportserial.c mbporttimer.c mbmconfig.h
software components: CMSIS:CORE 4.1.0
