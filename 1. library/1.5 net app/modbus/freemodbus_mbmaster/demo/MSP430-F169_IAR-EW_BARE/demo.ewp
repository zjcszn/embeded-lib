# IAR project demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F169 MSP430F169
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: System; port; ..\..\mbmaster\include
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f169.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: demo.c
  group MODBUS
    ../../mbmaster/: mbm.c
    ../../mbmaster/ascii/: mbmascii.c mbmascii.h
    ../../mbmaster/rtu/: mbmcrc.c mbmcrc.h mbmrtu.c mbmrtu.h
    ../../mbmaster/functions/: mbmfunccoils.c mbmfuncdisc.c mbmfuncholding.c mbmfuncinput.c mbmfuncslaveid.c
    ../../mbmaster/tcp/: mbmtcp.c mbmtcp.h
    ../../mbmaster/common/: mbutils.c
  group Port
    port/: mbmconfig.h mbport.h mbportevent.c mbportother.c mbportserial.c mbporttimer.c mbsconfig.h
  group System
    System/: DCO_Library.s43
