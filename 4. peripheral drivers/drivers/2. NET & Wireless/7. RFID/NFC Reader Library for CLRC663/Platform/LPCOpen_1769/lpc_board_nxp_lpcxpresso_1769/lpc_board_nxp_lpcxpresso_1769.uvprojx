# Keil uVision project lpc_board_nxp_lpcxpresso_1769.uvprojx, settings and files
target ReleaseLPC1769 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lpc_board_nxp_lpcxpresso_1769 (library)
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: .\inc;..\lpc_chip_175x_6x\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./src/: board.c board_sysinit.c lpc_phy_smsc87x0.c
target DebugLPC1769 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: lpc_board_nxp_lpcxpresso_1769 (library)
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: .\inc;..\lpc_chip_175x_6x\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
