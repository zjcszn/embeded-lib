# Keil uVision project lpc_chip_175x_6x.uvprojx, settings and files
target ReleaseLPC1769 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lpc_chip_175x_6x (library)
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group src
    ./src/: adc_17xx_40xx.c can_17xx_40xx.c chip_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c gpio_17xx_40xx.c gpioint_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iap.c iocon_17xx_40xx.c lcd_17xx_40xx.c pmu_17xx_40xx.c ring_buffer.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c stopwatch_17xx_40xx.c sysctl_17xx_40xx.c sysinit_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c wwdt_17xx_40xx.c
target DebugLPC1769 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: lpc_chip_175x_6x (library)
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
