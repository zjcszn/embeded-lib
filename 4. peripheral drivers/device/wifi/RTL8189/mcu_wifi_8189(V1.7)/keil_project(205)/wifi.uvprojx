# Keil uVision project wifi.uvprojx, settings and files
target mcu_wifi (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wifi +hex
  AfterMake: hex2bin.exe   .\out\wifi.hex
  c flags: Optim=1 wLevel=2
  c misc: --diag_suppress 1035,188,68,161,1441,111,61
  c include: ..\drivers\stm32f2xx\inc;..\bsp\stm32f2xx\CMSIS\inc;..\bsp\stm32f2xx\FWlib2xx\inc;..\net\lwip\src\include\ipv4;..\net\lwip\src\include;..\net\lwip\src\arch;..\net\lwip\src;..\kernel\ucos\include;..\kernel\api\inc;..\app\inc;..\config;..\net\udhcp-0.9.8;..\libmad-0.15.1b;..\net\libertas\inc;..\net\wpa;..\net\wlan_src\include;..\net\wlan_src\user;..\net\airkiss
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --remove
  group bsp
    ../bsp/stm32f2xx/FWlib2xx/src/: misc.c stm32f2xx_adc.c stm32f2xx_dac.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_dcmi.c stm32f2xx_sdio.c
    ../bsp/stm32f2xx/CMSIS/src/: system_stm32f2xx.c core_cm3.c startup_stm32f2xx.s
  group drivers
    ../drivers/stm32f2xx/src/: w25p80.c usart.c audio_low_level.c ov7670.c sccb.c sdcard.c driver_misc.c
  group os
    ../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_c.c os_cpu_a.asm
  group os_api
    ../kernel/api/src/: atomic.c mbox.c msg_q.c mutex.c sem.c task.c timer.c wait.c memory.c
  group lwip_api
    ../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ../net/lwip/src/arch/: sys_arch.c
  group lwip_core
    ../net/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../net/lwip/src/netif/: ethernetif.c etharp.c
  group udhcp
    ../net/udhcp-0.9.8/: dhcpd.c leases.c options.c packet.c serverpacket.c
  group wlan_core
    ../net/wlan_src/core/: rtw_ap.c rtw_br_ext.c rtw_cmd.c rtw_debug.c rtw_ieee80211.c rtw_io.c rtw_ioctl_set.c rtw_iol.c rtw_led.c rtw_mlme.c rtw_mlme_ext.c rtw_mp.c rtw_p2p.c rtw_pwrctrl.c rtw_recv.c rtw_rf.c rtw_sreset.c rtw_sta_mgt.c rtw_tdls.c rtw_wapi.c rtw_wapi_sms4.c rtw_wlan_util.c rtw_xmit.c rtw_security.c
    ../net/wlan_src/core/efuse/: rtw_efuse.c
  group wlan_hal
    ../net/wlan_src/hal/: hal_com.c hal_intf.c HalPwrSeqCmd.c
    ../net/wlan_src/hal/rtl8188e/sdio/: rtl8189es_led.c rtl8189es_recv.c rtl8189es_xmit.c sdio_halinit.c sdio_ops.c
    ../net/wlan_src/hal/OUTSRC/: HalPhyRf.c odm.c odm_debug.c odm_HWConfig.c odm_interface.c
    ../net/wlan_src/hal/OUTSRC/rtl8188e/: Hal8188EFWImg_CE.c Hal8188ERateAdaptive.c HalHWImg8188E_BB.c HalHWImg8188E_FW.c HalHWImg8188E_MAC.c HalHWImg8188E_RF.c HalPhyRf_8188e.c odm_RegConfig8188E.c odm_RTL8188E.c
    ../net/wlan_src/hal/rtl8188e/: rtl8188e_cmd.c rtl8188e_dm.c rtl8188e_hal_init.c rtl8188e_mp.c rtl8188e_phycfg.c rtl8188e_rf6052.c rtl8188e_rxdesc.c rtl8188e_sreset.c rtl8188e_xmit.c Hal8188EPwrSeq.c
  group wlan_os
    ../net/wlan_src/os_dep/: osdep_service.c
    ../net/wlan_src/os_dep/linux/: custom_gpio_linux.c ioctl_cfg80211.c mlme_linux.c os_intfs.c recv_linux.c sdio_intf.c sdio_ops_linux.c xmit_linux.c
  group wlan_user
    ../net/wlan_src/user/: usr_cfg.c skbuff.c moal_sdio_mmc.c
  group wpa
    ../net/wpa/: wpa.c sha1.c aes_core.c
  group airkiss
    ../net/airkiss/: airkiss.c
  group libmad
    ../libmad-0.15.1b/: bit.c decoder.c fixed.c frame.c huffman.c layer3.c layer12.c mad_timer.c madlld.c stream.c synth.c version.c
  group xrf_lib
    ../xrf_lib/: xrf_lib.lib
  group app
    ../app/src/: debug.c sys_misc.c main.c test_wifi.c test_tcpip.c tcpapp.c wifi_app.c airkiss_demo.c machtalk_remote_control.c webserver.c
    ../app/src/audio/: audio.c adpcm.c
