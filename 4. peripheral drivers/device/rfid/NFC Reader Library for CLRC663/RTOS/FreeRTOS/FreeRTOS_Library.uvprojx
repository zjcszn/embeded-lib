# Keil uVision project FreeRTOS_Library.uvprojx, settings and files
target ReleaseLPC1769 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Library (library)
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include;.\portable\RVDS\ARM_CM3;.\include;.\portable\GCC\ARM_CM3;..\..\NxpNfcRdLib\intfs;..\..\NxpNfcRdLib\types
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group common
    ./: croutine.c event_groups.c heap_3.c list.c phFreeRTOSConfig.c queue.c tasks.c timers.c
  group CM0
    ./portable/RVDS/ARM_CM0/: port.c
  group CM3
    ./portable/RVDS/ARM_CM3/: port.c
target DebugLPC1769 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1769 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: FreeRTOS_Library (library)
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include;.\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target ReleasePN7462AU (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: IROM(0x00203000,0x00027800) IROM2(0x00201200,0x00000E00) IRAM(0x00100020,0x2EE0) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FreeRTOS_Library (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include;.\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT5: ROM 0x201200 size 0xe00
  memory RVCT9: RAM 0x100020 size 0x2ee0
target DebugPN7462AU (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: PN7462AU-C3-00 NXP
  pack: NXP.PN7xxxxx.0.9.0
  cpu: as above
  output: FreeRTOS_Library (library)
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\include;.\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x203000 size 0x27800
  memory RVCT5: ROM 0x201200 size 0xe00
  memory RVCT9: RAM 0x100020 size 0x2ee0
